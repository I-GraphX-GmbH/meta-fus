# Remove u-boot-mfgtool dependency
# for it expects UBOOT_CONFIG
# instead of UBOOT_MACHINE

DEPENDS_remove = "u-boot-mfgtool"
