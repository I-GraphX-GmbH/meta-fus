# Use newer version with bugfixes
SRCREV = "7859a762617682bd804e210ad3bda6bdcd3ea24a"
