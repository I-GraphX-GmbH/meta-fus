#FuS alsa-state should be used


# Update asound.conf for all SoC
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


