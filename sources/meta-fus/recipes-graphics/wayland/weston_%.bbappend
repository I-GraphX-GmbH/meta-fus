# For resistive touch panels a calibrator is needed
# so insert the one from Wayland/Weston

FILES_${PN} += "${bindir}/weston-touch-calibrator"
