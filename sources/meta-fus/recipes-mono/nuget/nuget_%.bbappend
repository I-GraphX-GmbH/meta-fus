
# Otherwise the Manifest can not be found
inherit allarch

