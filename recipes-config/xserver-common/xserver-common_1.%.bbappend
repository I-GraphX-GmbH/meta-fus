DESCRIPTON = "fix ls command in Xsession shell"

FILESEXTRAPATHS:prepend := "${THISDIR}/xserver-common:"
SRC_URI += "file://0017-fix-ls-command.patch"
