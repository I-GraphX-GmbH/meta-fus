DESCRIPTON = "add german keyboard layout"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0010-add-german-layout.patch"
