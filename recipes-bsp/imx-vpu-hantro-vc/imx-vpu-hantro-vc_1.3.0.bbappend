# Copyright 2020 F&S Elektronik Systeme GmbH

COMPATIBLE_MACHINE = "(fsimx8mp)"

